# Keil uVision project 时钟项目.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 时钟项目 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h Buzzer.c Buzzer.h DS1302.c DS1302.h Key.c Key.h LCD1602.c LCD1602.h Nixie.c Nixie.h Timer0.c Timer0.h
